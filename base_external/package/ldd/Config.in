## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd"
    help
      Builds ldd3 misc-modules and scull kernel modules
```
